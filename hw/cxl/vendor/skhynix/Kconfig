## hw/cxl/vendor/skhynix/Kconfig
```kconfig
config CXL_SKHYNIX_NIAGARA
    bool
    depends on CXL_MEM_DEVICE && LINUX
    default y if CXL_VENDOR
```
